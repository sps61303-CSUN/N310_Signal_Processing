options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 3e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: run_time
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(run_time*samp_rate)-1
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 192.168.56.101
    noblock: 'True'
    port: '2000'
    type: complex
    vlen: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    fc: center_freq
    fftsize: '1024'
    nconnections: '4'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    bw0: bandwidth
    bw1: bandwidth
    bw2: bandwidth
    bw3: bandwidth
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_source0: internal
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dc_offs_enb2: 'False'
    dc_offs_enb3: 'False'
    dev_addr: addr=192.168.10.2
    dev_args: rx_lo_source=internal,init_cals=BASIC|TX_ATTENUATION_DELAY|RX_GAIN_DELAY|PATH_DELAY|TX_LO_LEAKAGE_INTERNAL|LOOPBACK_RX_LO_DELAY
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    iq_imbal_enb2: 'False'
    iq_imbal_enb3: 'False'
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    rx_agc0: Disabled
    rx_agc1: Disabled
    rx_agc2: Disabled
    rx_agc3: Disabled
    samp_rate: samp_rate
    sd_spec0: '"A:0 A:1 B:0 B:1"'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_null_sink_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_tcp_server_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', blocks_streams_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_streams_to_vector_0, '1']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '2', blocks_streams_to_vector_0, '2']
- [uhd_usrp_source_0, '2', qtgui_freq_sink_x_0, '2']
- [uhd_usrp_source_0, '3', blocks_streams_to_vector_0, '3']
- [uhd_usrp_source_0, '3', qtgui_freq_sink_x_0, '3']

metadata:
  file_format: 1
