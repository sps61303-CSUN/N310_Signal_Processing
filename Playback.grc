options:
  parameters:
    generate_options: no_gui
    id: Replay
    output_language: cpp
    title: Replay
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: run_time
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/sf_ShareFolder/RF2GHz
    repeat: 'True'
    type: complex
    vlen: '4'
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 192.168.56.101
    noblock: 'True'
    port: '2000'
    type: complex
    vlen: '4'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '4'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_tcp_server_sink_0, '0']

metadata:
  file_format: 1
